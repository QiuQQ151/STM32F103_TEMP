# Keil uVision project stm32f103.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: stm32f103 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\DRIVER\CMSIS;..\USER;..\DRIVER\FWLIB;..\DRIVER\FWLIB\inc;..\MIDWARE\FreeRTOS;..\MIDWARE\FreeRTOS\include;..\MIDWARE\FreeRTOS\portable\RVDS\ARM_CM3;..\DRIVER\BSP\LED;..\DRIVER\BSP\BUZZER;..\DRIVER\BSP\TFT2.8;..\DRIVER\MYDRIVE;..\DRIVER\BSP\DHT11;..\DRIVER\BSP\SRAM;..\USER\THERMOMETER;..\DRIVER\BSP\24CXX;..\USER\FONT;..\DRIVER\BSP\FLASH;..\MIDWARE\FATFS\exfuns;..\MIDWARE\FATFS\source;..\DRIVER\BSP\SD
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT6: RAM 0x68000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group DRIVER/CMSIS
    ../DRIVER/CMSIS/: core_cm3.c core_cm3.h startup_stm32f10x_hd.s stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group DRIVER/FWLIB
    ../DRIVER/FWLIB/: stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h
    ../DRIVER/FWLIB/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group DRIVER/mydrive
    ../DRIVER/MYDRIVE/: adc.c adc.h myiic.c myiic.h pwm.c pwm.h spi.c spi.h delay.c delay.h
  group DRIVER/BSP
    ../DRIVER/BSP/LED/: led.c led.h
    ../DRIVER/BSP/BUZZER/: buzzer.c buzzer.h
    ../DRIVER/BSP/TFT2.8/: FONT.H lcd.c lcd.h GUI.c GUI.h
    ../DRIVER/BSP/DHT11/: DHT11.c DHT11.h
    ../DRIVER/BSP/SRAM/: sram.c sram.h
    ../DRIVER/BSP/24CXX/: 24cxx.c 24cxx.h
    ../DRIVER/BSP/SD/: mmc_sd.c mmc_sd.h
    ../DRIVER/BSP/FLASH/: flash.c flash.h
  group MIDWARE/FreeRTOS
    ../MIDWARE/FreeRTOS/: croutine.c event_groups.c FreeRTOSConfig.h list.c queue.c stream_buffer.c tasks.c timers.c
    ../MIDWARE/FreeRTOS/portable/RVDS/ARM_CM3/: port.c portmacro.h
    ../MIDWARE/FreeRTOS/portable/MemMang/: heap_4.c
  group MIDWARE/FATFS
    ../MIDWARE/FATFS/exfuns/: exfuns.c exfuns.h fattester.c fattester.h mycc936.c
    ../MIDWARE/FATFS/source/: 00history.txt 00readme.txt diskio.c diskio.h ff.c ff.h ffconf.h ffsystem.c ffunicode.c integer.h
  group USER/THERMOMETER
    ../USER/THERMOMETER/: thermometer_app.c thermometer_app.h
  group USER/FONT
    ../USER/FONT/: fontupdate.c fontupdate.h
  group USER
    ../USER/: main.c pic.h test.c test.h mytask.c mytask.h
